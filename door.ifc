Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView]
File name: door.ifc
Time: 2026-09-09T00:00:00
Author: INVISIBLE DOORS
Organization: INVISIBLE DOORS
Written by: Showroom R15
Made in: Showroom R15

# IfcBuildingStorey, Finished floor
In: Building
Elevation: 0 m

# IfcDoor, Двустворчатая
In: Finished floor
Description: Coordination geometry; not a native wall-hosted family; OverallHeight: 2.0583 m; OverallWidth: 0.8966 m; PredefinedType: DOOR; OperationType: DOUBLE_DOOR_SINGLE_SWING
INVISIBLE_DOORS_Configuration - Manufacturer: INVISIBLE DOORS; Model: skrytaya-dver; Finish: RAL 7032; FinishOutside: Эмаль · RAL 7032 · матовая; FinishInside: Как снаружи · Эмаль · RAL 7032 · матовая; Opening: right-out; Source: https://invisible-doors.ru/public_files/recommendations.pdf; GeometryUse: interior visualisation and coordination; operator GLB frame section; simplified hardware; LeafWidthMm: 800; LeafHeightMm: 2000; LeafThicknessMm: 55; FrameProfile: АД-3П-5 Алком; FrameSectionMm: 59 x 44.3; FrameSourceSHA256: fe69c8d856e3883ac607518ee982475fb0650ab636a780c19748035ef0f4edc7
